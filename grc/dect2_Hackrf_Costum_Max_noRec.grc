<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>LNA_rf_gain</value></param>
<param><key>value</key><value>14</value></param>
<param><key>label</key><value>LNA RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>14</value></param>
<param><key>stop</key><value>14</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>VGA_bb_gain</value></param>
<param><key>value</key><value>34</value></param>
<param><key>label</key><value>VGA BB Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>2</value></param>
<param><key>stop</key><value>62</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_sampling_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dect_channel_bandwidth</value></param>
<param><key>value</key><value>1.728e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dect_occupied_bandwidth</value></param>
<param><key>value</key><value>1.2*dect_symbol_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dect_symbol_rate</value></param>
<param><key>value</key><value>1152000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>8</value></param>
<param><key>stop</key><value>40</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>options_low_pass</value></param>
<param><key>value</key><value>1400500</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id</value></param>
<param><key>value</key><value>8</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_1</value></param>
<param><key>value</key><value>7</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_2</value></param>
<param><key>value</key><value>6</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_3</value></param>
<param><key>value</key><value>5</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_4</value></param>
<param><key>value</key><value>4</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_5</value></param>
<param><key>value</key><value>3</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_6</value></param>
<param><key>value</key><value>2</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_7</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>part_id_8</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Select Part</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2, 3, 4, 5, 6, 7, 8]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm_corr</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 3*baseband_sampling_rate, dect_occupied_bandwidth/2, (dect_channel_bandwidth - dect_occupied_bandwidth)/2, 30)</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>1897344000</value></param>
<param><key>label</key><value>Carrier Number</value></param>
<param><key>labels</key><value>["0", "1", "2", "3", "4", "5", "6", "7", "8", "9"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[ 1897344000, 1895616000, 1893888000, 1892160000, 1890432000, 1888704000, 1886876000, 1885248000, 1883520000, 1881792000]</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_offset1</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_1</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_3</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_4</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_5</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_6</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0_0</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_1</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_2</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_3</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_4</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_5</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_6</value></param>
<param><key>scale</key><value>32768</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_0</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_0_0</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_1</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_2</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_3</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_4</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_5</value></param>
</block>
<block>
<key>console</key>
<param><key>id</key><value>console_0_6</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0</value></param>
<param><key>rx_id</key><value>part_id</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_0</value></param>
<param><key>rx_id</key><value>part_id_1</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_1</value></param>
<param><key>rx_id</key><value>part_id_2</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_1_0</value></param>
<param><key>rx_id</key><value>part_id_8</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_2</value></param>
<param><key>rx_id</key><value>part_id_3</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_3</value></param>
<param><key>rx_id</key><value>part_id_4</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_4</value></param>
<param><key>rx_id</key><value>part_id_5</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_5</value></param>
<param><key>rx_id</key><value>part_id_6</value></param>
</block>
<block>
<key>dect2_packet_decoder</key>
<param><key>id</key><value>dect2_packet_decoder_0_6</value></param>
<param><key>rx_id</key><value>part_id_7</value></param>
</block>
<block>
<key>dect2_packet_receiver</key>
<param><key>id</key><value>dect2_packet_receiver_0</value></param>
</block>
<block>
<key>dect2_phase_diff</key>
<param><key>id</key><value>dect2_phase_diff_0</value></param>
</block>
<block>
<key>fractional_resampler_xx</key>
<param><key>id</key><value>fractional_resampler</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>resamp_ratio</key><value>(3.0*baseband_sampling_rate/2.0)/dect_symbol_rate/4.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>xlate_offset1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>baseband_sampling_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, baseband_sampling_rate, options_low_pass, options_low_pass*0.2)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_base_xxx</key>
<param><key>id</key><value>rational_resampler</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>interp</key><value>3</value></param>
<param><key>taps</key><value>resampler_filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_4</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_5</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_6</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>6</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>VGA_bb_gain</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>ppm_corr</value></param>
<param><key>freq0</key><value>rx_freq-xlate_offset1</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>LNA_rf_gain</value></param>
<param><key>args</key><value>hackrf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>baseband_sampling_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_0</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_0_0</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_1</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_2</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_3</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_4</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_5</value></param>
</block>
<block>
<key>vocoder_g721_decode_bs</key>
<param><key>id</key><value>vocoder_g721_decode_bs_0_6</value></param>
</block>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_1</source_block_id><sink_block_id>rational_resampler_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_2</source_block_id><sink_block_id>rational_resampler_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_3</source_block_id><sink_block_id>rational_resampler_xxx_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_4</source_block_id><sink_block_id>rational_resampler_xxx_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_5</source_block_id><sink_block_id>rational_resampler_xxx_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_6</source_block_id><sink_block_id>rational_resampler_xxx_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0</source_block_id><sink_block_id>console_0</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0</source_block_id><sink_block_id>vocoder_g721_decode_bs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_0</source_block_id><sink_block_id>console_0_0</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_0</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_1</source_block_id><sink_block_id>console_0_1</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_1</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_1_0</source_block_id><sink_block_id>console_0_0_0</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_1_0</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_2</source_block_id><sink_block_id>console_0_2</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_2</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_3</source_block_id><sink_block_id>console_0_3</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_3</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_4</source_block_id><sink_block_id>console_0_4</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_4</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_5</source_block_id><sink_block_id>console_0_5</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_5</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_6</source_block_id><sink_block_id>console_0_6</sink_block_id><source_key>log_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dect2_packet_decoder_0_6</source_block_id><sink_block_id>vocoder_g721_decode_bs_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_0</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_1</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_1_0</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_2</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_3</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_4</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_5</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_packet_receiver_0</source_block_id><sink_block_id>dect2_packet_decoder_0_6</sink_block_id><source_key>rcvr_msg_out</source_key><sink_key>rcvr_msg_in</sink_key></connection>
<connection><source_block_id>dect2_phase_diff_0</source_block_id><sink_block_id>dect2_packet_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_resampler</source_block_id><sink_block_id>dect2_phase_diff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler</source_block_id><sink_block_id>fractional_resampler</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>audio_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_1</source_block_id><sink_block_id>audio_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_2</source_block_id><sink_block_id>audio_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_3</source_block_id><sink_block_id>audio_sink_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_4</source_block_id><sink_block_id>audio_sink_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_5</source_block_id><sink_block_id>audio_sink_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_6</source_block_id><sink_block_id>audio_sink_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_0_0</source_block_id><sink_block_id>blocks_short_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_1</source_block_id><sink_block_id>blocks_short_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_2</source_block_id><sink_block_id>blocks_short_to_float_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_3</source_block_id><sink_block_id>blocks_short_to_float_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_4</source_block_id><sink_block_id>blocks_short_to_float_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_5</source_block_id><sink_block_id>blocks_short_to_float_0_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_g721_decode_bs_0_6</source_block_id><sink_block_id>blocks_short_to_float_0_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
